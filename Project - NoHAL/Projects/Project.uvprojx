# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Objects
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F103xE,USE_HAL_DRIVER_
  c misc: --C99
  c include: ..\Applications\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\STM32F1xx\Include;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\RTOS;..\Middlewares\FreeRTOS\Source\CMSIS_RTOS;..\Middlewares\FreeRTOS\Source\include;..\Middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\Firmware\Middlewares\FreeRTOS\Source\portable\Keil;..\Firmware\Middlewares\FreeRTOS\Source\CMSIS_RTOS;..\Firmware\Middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\Firmware\Drivers\BSP\STM3210E_EVAL;..\Application\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Linker.sct
  link misc: --diag_suppress=L6329
  group Startup
    ../Drivers/STM32F1xx/Source/: startup_stm32f103xe.s
  group Application
    ../Drivers/STM32F1xx/Source/: system_stm32f1xx.c
    ../Applications/Src/: main.c stm32f1xx_it.c
  group FreeRTOS
    ../Middlewares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
